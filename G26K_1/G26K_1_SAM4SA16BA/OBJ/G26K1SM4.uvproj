# Keil uVision project G26K1SM4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: SAM4SA16B Atmel
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0x400000-0x4FFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")
  output: G26K1SM4
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Source Group 1
    ./: startup_SAM4S.s main.cpp system_SAM4S.cpp
